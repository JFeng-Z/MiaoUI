<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_optx.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj; *.o</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
    <nMigrate>0</nMigrate>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>STM32F103C8T6</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>12000000</CLKADS>
      <OPTTT>
        <gFlags>0</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>0</RunSim>
        <RunTarget>1</RunTarget>
        <RunAbUc>0</RunAbUc>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\build\Keil\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>0</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>18</CpuCode>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <tRtrace>1</tRtrace>
        <sRSysVw>1</sRSysVw>
        <tRSysVw>1</tRSysVw>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <bEvRecOn>1</bEvRecOn>
        <nTsel>0</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>BIN\UL2CM3.DLL</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>UL2CM3(-S0 -C0 -P0 -FD20000000 -FC1000 -FN1 -FF0STM32F10x_128 -FS08000000 -FL020000 -FP0($$Device:STM32F103C8$Flash\STM32F10x_128.FLM))</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint/>
      <Tracepoint>
        <THDelay>0</THDelay>
      </Tracepoint>
      <DebugFlag>
        <trace>0</trace>
        <periodic>0</periodic>
        <aLwin>0</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>0</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
      <bLintAuto>0</bLintAuto>
      <bAutoGenD>0</bAutoGenD>
      <LntExFlags>0</LntExFlags>
      <pMisraName></pMisraName>
      <pszMrule></pszMrule>
      <pSingCmds></pSingCmds>
      <pMultCmds></pMultCmds>
      <pMisraNamep></pMisraNamep>
      <pszMrulep></pszMrulep>
      <pSingCmdsp></pSingCmdsp>
      <pMultCmdsp></pMultCmdsp>
      <DebugDescription>
        <Enable>1</Enable>
        <EnableLog>0</EnableLog>
        <Protocol>2</Protocol>
        <DbgClock>10000000</DbgClock>
      </DebugDescription>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>HAL/STM32F10X_STDPERIPH_DRIVER</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/startup_stm32f10x_md.s</PathWithFileName>
      <FilenameWithoutPath>startup_stm32f10x_md.s</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/stm32f10x_it.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_it.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/system_stm32f10x.c</PathWithFileName>
      <FilenameWithoutPath>system_stm32f10x.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>HAL/STM32F10X_STDPERIPH_DRIVER/SRC</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/misc.c</PathWithFileName>
      <FilenameWithoutPath>misc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_adc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_adc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_bkp.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_bkp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_can.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_can.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>8</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_cec.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_cec.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>9</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_crc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_crc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>10</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_dac.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_dac.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>11</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_dbgmcu.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_dbgmcu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>12</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_dma.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_dma.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>13</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_exti.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_exti.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>14</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_flash.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_flash.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>15</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_fsmc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_fsmc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>16</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_gpio.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_gpio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>17</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_i2c.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_i2c.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>18</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_iwdg.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_iwdg.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>19</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_pwr.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_pwr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>20</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_rcc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_rcc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>21</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_rtc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_rtc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>22</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_sdio.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_sdio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>23</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_spi.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_spi.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>24</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_tim.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_tim.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>25</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_usart.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_usart.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>26</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>hal/STM32F10x_StdPeriph_Driver/src/stm32f10x_wwdg.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_wwdg.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/UGL</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>27</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/ugl/ugl_arrays.c</PathWithFileName>
      <FilenameWithoutPath>ugl_arrays.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>28</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/ugl/ugl_bc.c</PathWithFileName>
      <FilenameWithoutPath>ugl_bc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>29</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/ugl/ugl_error.c</PathWithFileName>
      <FilenameWithoutPath>ugl_error.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>30</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/ugl/ugl_main.c</PathWithFileName>
      <FilenameWithoutPath>ugl_main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>31</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/ugl/ugl_parse.c</PathWithFileName>
      <FilenameWithoutPath>ugl_parse.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/PNG2BIN</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>32</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/png2bin/png2bin.c</PathWithFileName>
      <FilenameWithoutPath>png2bin.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/MDTOC</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>33</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/mdtoc/mdtoc.c</PathWithFileName>
      <FilenameWithoutPath>mdtoc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/MAZE</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>34</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/maze/maze.c</PathWithFileName>
      <FilenameWithoutPath>maze.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/INTERSECTION</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>35</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/intersection/intersection.c</PathWithFileName>
      <FilenameWithoutPath>intersection.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/INOUPDATE</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>36</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/inoupdate/inoupdate.c</PathWithFileName>
      <FilenameWithoutPath>inoupdate.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/FONT/PNG2BDF</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>37</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/png2bdf/png2bdf.c</PathWithFileName>
      <FilenameWithoutPath>png2bdf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/FONT/PNG2BDF/TEST</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>10</GroupNumber>
      <FileNumber>38</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/png2bdf/test/track_font.c</PathWithFileName>
      <FilenameWithoutPath>track_font.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/FONT/PBM</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>11</GroupNumber>
      <FileNumber>39</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/pbm/pbm.c</PathWithFileName>
      <FilenameWithoutPath>pbm.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/FONT/OTF2BDF</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>12</GroupNumber>
      <FileNumber>40</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/otf2bdf/otf2bdf.c</PathWithFileName>
      <FilenameWithoutPath>otf2bdf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
      <FileNumber>41</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/otf2bdf/remap.c</PathWithFileName>
      <FilenameWithoutPath>remap.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/FONT/CODESEARCH</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>42</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/codesearch/codesearch.c</PathWithFileName>
      <FilenameWithoutPath>codesearch.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/FONT/BUILD</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>14</GroupNumber>
      <FileNumber>43</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/build.c</PathWithFileName>
      <FilenameWithoutPath>build.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>14</GroupNumber>
      <FileNumber>44</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/u8g2_d_tga.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_d_tga.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>14</GroupNumber>
      <FileNumber>45</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/u8g2_font_list.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_list.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>14</GroupNumber>
      <FileNumber>46</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/u8x8_font_list.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_list.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/FONT/BUILD/SINGLE_FONT_FILES</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>47</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_04b_03b_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_04b_03b_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>48</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_04b_03_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_04b_03_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>49</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_10x20_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_10x20_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>50</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_10x20_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_10x20_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>51</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_10x20_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_10x20_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>52</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_10x20_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_10x20_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>53</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_10x20_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_10x20_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>54</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_10x20_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_10x20_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>55</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_10x20_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_10x20_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>56</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_10x20_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_10x20_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>57</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_10x20_t_arabic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_10x20_t_arabic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>58</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_10x20_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_10x20_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>59</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_10x20_t_greek.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_10x20_t_greek.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>60</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_12x6LED_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_12x6LED_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>61</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_12x6LED_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_12x6LED_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>62</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_12x6LED_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_12x6LED_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>63</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_3x3basic_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_3x3basic_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>64</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_3x5im_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_3x5im_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>65</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_3x5im_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_3x5im_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>66</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_3x5im_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_3x5im_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>67</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_4x6_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_4x6_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>68</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_4x6_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_4x6_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>69</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_4x6_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_4x6_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>70</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_4x6_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_4x6_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>71</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_4x6_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_4x6_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>72</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_4x6_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_4x6_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>73</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_4x6_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_4x6_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>74</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_5x7_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_5x7_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>75</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_5x7_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_5x7_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>76</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_5x7_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_5x7_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>77</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_5x7_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_5x7_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>78</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_5x7_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_5x7_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>79</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_5x7_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_5x7_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>80</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_5x7_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_5x7_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>81</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_5x8_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_5x8_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>82</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_5x8_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_5x8_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>83</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_5x8_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_5x8_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>84</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_5x8_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_5x8_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>85</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_5x8_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_5x8_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>86</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_5x8_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_5x8_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>87</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_5x8_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_5x8_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>88</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x10_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x10_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>89</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x10_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x10_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>90</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x10_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x10_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>91</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>92</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>93</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>94</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x12_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x12_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>95</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x12_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x12_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>96</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x12_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x12_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>97</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x12_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x12_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>98</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x12_m_symbols.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x12_m_symbols.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>99</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x12_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x12_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>100</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>101</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>102</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>103</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x12_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x12_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>104</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x12_t_symbols.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x12_t_symbols.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>105</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13B_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13B_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>106</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13B_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13B_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>107</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13B_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13B_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>108</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13B_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13B_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>109</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13B_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13B_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>110</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13B_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13B_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>111</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13B_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13B_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>112</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13B_t_hebrew.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13B_t_hebrew.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>113</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13O_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13O_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>114</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13O_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13O_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>115</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13O_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13O_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>116</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13O_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13O_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>117</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13O_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13O_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>118</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13O_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13O_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>119</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>120</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>121</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>122</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>123</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>124</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>125</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>126</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>127</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>128</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_6x13_t_hebrew.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_6x13_t_hebrew.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>129</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7Segments_26x42_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7Segments_26x42_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>130</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13B_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13B_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>131</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13B_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13B_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>132</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13B_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13B_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>133</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13B_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13B_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>134</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13B_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13B_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>135</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13B_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13B_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>136</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13O_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13O_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>137</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13O_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13O_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>138</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13O_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13O_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>139</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13O_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13O_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>140</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13O_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13O_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>141</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13O_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13O_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>142</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>143</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>144</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>145</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>146</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13_m_symbols.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13_m_symbols.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>147</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>148</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>149</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>150</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>151</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>152</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x13_t_symbols.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x13_t_symbols.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>153</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x14B_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x14B_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>154</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x14B_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x14B_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>155</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x14B_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x14B_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>156</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x14B_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x14B_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>157</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x14B_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x14B_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>158</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x14B_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x14B_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>159</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x14_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x14_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>160</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x14_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x14_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>161</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x14_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x14_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>162</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>163</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>164</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7x14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7x14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>165</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7_Seg_33x19_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7_Seg_33x19_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>166</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_7_Seg_41x21_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_7_Seg_41x21_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>167</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8bitclassic_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8bitclassic_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>168</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8bitclassic_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8bitclassic_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>169</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8bitclassic_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8bitclassic_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>170</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13B_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13B_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>171</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13B_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13B_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>172</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13B_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13B_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>173</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13B_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13B_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>174</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13B_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13B_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>175</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13B_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13B_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>176</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13O_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13O_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>177</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13O_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13O_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>178</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13O_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13O_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>179</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13O_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13O_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>180</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13O_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13O_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>181</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13O_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13O_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>182</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>183</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>184</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>185</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>186</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13_m_symbols.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13_m_symbols.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>187</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>188</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>189</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>190</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>191</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>192</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_8x13_t_symbols.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_8x13_t_symbols.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>193</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15B_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15B_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>194</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15B_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15B_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>195</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15B_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15B_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>196</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15B_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15B_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>197</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15B_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15B_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>198</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15B_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15B_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>199</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>200</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>201</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>202</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>203</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15_m_symbols.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15_m_symbols.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>204</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>205</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>206</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>207</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>208</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>209</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x15_t_symbols.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x15_t_symbols.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>210</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x18B_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x18B_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>211</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x18B_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x18B_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>212</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x18B_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x18B_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>213</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x18B_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x18B_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>214</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x18B_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x18B_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>215</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x18B_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x18B_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>216</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x18_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x18_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>217</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x18_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x18_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>218</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x18_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x18_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>219</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>220</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>221</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>222</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x6LED_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x6LED_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>223</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x6LED_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x6LED_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>224</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_9x6LED_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_9x6LED_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>225</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_abel_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_abel_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>226</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_adventurer_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_adventurer_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>227</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_adventurer_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_adventurer_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>228</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_adventurer_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_adventurer_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>229</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_amstrad_cpc_extended_8f.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_amstrad_cpc_extended_8f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>230</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_amstrad_cpc_extended_8n.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_amstrad_cpc_extended_8n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>231</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_amstrad_cpc_extended_8r.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_amstrad_cpc_extended_8r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>232</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_amstrad_cpc_extended_8u.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_amstrad_cpc_extended_8u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>233</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_artossans8_8n.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_artossans8_8n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>234</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_artossans8_8r.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_artossans8_8r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>235</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_artossans8_8u.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_artossans8_8u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>236</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_artosserif8_8n.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_artosserif8_8n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>237</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_artosserif8_8r.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_artosserif8_8r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>238</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_artosserif8_8u.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_artosserif8_8u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>239</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_astragal_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_astragal_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>240</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_astragal_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_astragal_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>241</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_astragal_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_astragal_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>242</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b10_b_t_japanese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b10_b_t_japanese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>243</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b10_b_t_japanese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b10_b_t_japanese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>244</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b10_t_japanese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b10_t_japanese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>245</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b10_t_japanese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b10_t_japanese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>246</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b12_b_t_japanese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b12_b_t_japanese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>247</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b12_b_t_japanese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b12_b_t_japanese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>248</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b12_b_t_japanese3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b12_b_t_japanese3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>249</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b12_t_japanese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b12_t_japanese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>250</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b12_t_japanese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b12_t_japanese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>251</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b12_t_japanese3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b12_t_japanese3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>252</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b16_b_t_japanese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b16_b_t_japanese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>253</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b16_b_t_japanese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b16_b_t_japanese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>254</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b16_b_t_japanese3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b16_b_t_japanese3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>255</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b16_t_japanese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b16_t_japanese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>256</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b16_t_japanese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b16_t_japanese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>257</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_b16_t_japanese3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_b16_t_japanese3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>258</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_baby_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_baby_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>259</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_baby_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_baby_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>260</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_baby_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_baby_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>261</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_balthasar_regular_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_balthasar_regular_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>262</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_balthasar_regular_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_balthasar_regular_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>263</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_balthasar_regular_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_balthasar_regular_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>264</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_balthasar_titling_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_balthasar_titling_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>265</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_balthasar_titling_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_balthasar_titling_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>266</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_balthasar_titling_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_balthasar_titling_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>267</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_battery19_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_battery19_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>268</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_battery24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_battery24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>269</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bauhaus2015_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bauhaus2015_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>270</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bauhaus2015_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bauhaus2015_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>271</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_BBSesque_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_BBSesque_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>272</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_BBSesque_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_BBSesque_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>273</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_BBSesque_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_BBSesque_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>274</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_beanstalk_mel_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_beanstalk_mel_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>275</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_beanstalk_mel_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_beanstalk_mel_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>276</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bitcasual_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bitcasual_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>277</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bitcasual_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bitcasual_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>278</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bitcasual_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bitcasual_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>279</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bitcasual_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bitcasual_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>280</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bitcasual_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bitcasual_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>281</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_BitTypeWriter_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_BitTypeWriter_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>282</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_BitTypeWriter_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_BitTypeWriter_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>283</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_blipfest_07_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_blipfest_07_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>284</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_blipfest_07_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_blipfest_07_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>285</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Born2bSportySlab_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Born2bSportySlab_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>286</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Born2bSportySlab_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Born2bSportySlab_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>287</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Born2bSportySlab_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Born2bSportySlab_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>288</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Born2bSportySlab_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Born2bSportySlab_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>289</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Born2bSportyV2_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Born2bSportyV2_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>290</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Born2bSportyV2_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Born2bSportyV2_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>291</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Born2bSportyV2_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Born2bSportyV2_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>292</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_botmaker_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_botmaker_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>293</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_7x7_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_7x7_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>294</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_7x7_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_7x7_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>295</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_7x7_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_7x7_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>296</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_7x7_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_7x7_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>297</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_7x7_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_7x7_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>298</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_7x7_t_chinese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_7x7_t_chinese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>299</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_7x7_t_chinese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_7x7_t_chinese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>300</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_7x7_t_chinese3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_7x7_t_chinese3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>301</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_7x7_t_gb2312.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_7x7_t_gb2312.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>302</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_7x7_t_gb2312a.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_7x7_t_gb2312a.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>303</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_7x7_t_gb2312b.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_7x7_t_gb2312b.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>304</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_bold_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_bold_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>305</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_bold_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_bold_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>306</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_bold_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_bold_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>307</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_bold_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_bold_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>308</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_bold_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_bold_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>309</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_bold_t_chinese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_bold_t_chinese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>310</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_bold_t_chinese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_bold_t_chinese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>311</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_bold_t_chinese3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_bold_t_chinese3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>312</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_bold_t_gb2312.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_bold_t_gb2312.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>313</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_bold_t_gb2312a.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_bold_t_gb2312a.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>314</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_bold_t_gb2312b.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_bold_t_gb2312b.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>315</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>316</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>317</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>318</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>319</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>320</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_t_chinese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_t_chinese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>321</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_t_chinese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_t_chinese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>322</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_t_chinese3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_t_chinese3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>323</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_t_gb2312.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_t_gb2312.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>324</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_t_gb2312a.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_t_gb2312a.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>325</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_boutique_bitmap_9x9_t_gb2312b.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_boutique_bitmap_9x9_t_gb2312b.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>326</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bpixeldouble_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bpixeldouble_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>327</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bpixel_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bpixel_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>328</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bpixel_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bpixel_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>329</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bracketedbabies_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bracketedbabies_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>330</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bubble_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bubble_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>331</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bubble_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bubble_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>332</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_busdisplay11x5_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_busdisplay11x5_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>333</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_busdisplay11x5_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_busdisplay11x5_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>334</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_busdisplay8x5_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_busdisplay8x5_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>335</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bytesize_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bytesize_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>336</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bytesize_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bytesize_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>337</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_bytesize_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_bytesize_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>338</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_calblk36_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_calblk36_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>339</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_calibration_gothic_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_calibration_gothic_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>340</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_calibration_gothic_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_calibration_gothic_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>341</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_calibration_gothic_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_calibration_gothic_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>342</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_calibration_gothic_nbp_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_calibration_gothic_nbp_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>343</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_callite24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_callite24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>344</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cardimon_pixel_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cardimon_pixel_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>345</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cardimon_pixel_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cardimon_pixel_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>346</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cardimon_pixel_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cardimon_pixel_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>347</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_celibatemonk_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_celibatemonk_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>348</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_chargen_92_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_chargen_92_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>349</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_chargen_92_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_chargen_92_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>350</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_chargen_92_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_chargen_92_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>351</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_chargen_92_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_chargen_92_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>352</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_chargen_92_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_chargen_92_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>353</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_chargen_92_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_chargen_92_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>354</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_chargen_92_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_chargen_92_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>355</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_chargen_92_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_chargen_92_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>356</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_chikita_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_chikita_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>357</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_chikita_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_chikita_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>358</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_chikita_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_chikita_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>359</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_chroma48medium8_8n.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_chroma48medium8_8n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>360</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_chroma48medium8_8r.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_chroma48medium8_8r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>361</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_chroma48medium8_8u.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_chroma48medium8_8u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>362</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ciircle13_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ciircle13_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>363</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_commodore64_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_commodore64_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>364</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>365</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>366</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>367</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>368</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>369</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>370</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>371</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>372</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>373</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>374</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>375</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>376</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>377</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>378</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>379</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>380</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>381</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courB24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courB24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>382</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>383</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>384</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>385</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>386</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>387</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>388</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>389</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>390</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>391</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>392</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>393</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>394</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>395</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>396</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>397</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>398</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>399</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_courR24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_courR24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>400</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1cb_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1cb_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>401</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1cb_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1cb_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>402</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1cb_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1cb_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>403</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1cb_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1cb_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>404</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1cb_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1cb_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>405</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1cb_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1cb_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>406</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1c_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1c_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>407</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1c_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1c_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>408</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1c_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1c_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>409</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1c_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1c_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>410</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1c_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1c_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>411</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1c_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1c_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>412</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1hb_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1hb_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>413</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1hb_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1hb_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>414</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1hb_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1hb_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>415</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1h_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1h_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>416</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1h_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1h_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>417</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1h_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1h_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>418</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1tb_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1tb_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>419</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1tb_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1tb_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>420</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1tb_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1tb_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>421</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1t_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1t_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>422</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1t_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1t_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>423</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox1t_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox1t_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>424</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2cb_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2cb_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>425</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2cb_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2cb_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>426</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2cb_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2cb_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>427</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2cb_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2cb_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>428</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2cb_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2cb_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>429</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2cb_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2cb_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>430</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2c_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2c_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>431</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2c_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2c_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>432</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2c_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2c_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>433</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2c_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2c_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>434</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2c_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2c_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>435</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2c_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2c_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>436</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2hb_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2hb_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>437</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2hb_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2hb_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>438</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2hb_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2hb_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>439</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2h_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2h_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>440</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2h_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2h_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>441</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2h_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2h_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>442</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2tb_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2tb_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>443</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2tb_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2tb_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>444</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2tb_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2tb_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>445</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2t_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2t_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>446</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2t_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2t_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>447</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox2t_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox2t_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>448</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3cb_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3cb_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>449</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3cb_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3cb_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>450</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3cb_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3cb_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>451</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3cb_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3cb_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>452</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3cb_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3cb_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>453</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3cb_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3cb_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>454</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3c_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3c_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>455</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3c_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3c_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>456</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3c_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3c_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>457</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3c_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3c_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>458</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3c_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3c_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>459</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3c_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3c_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>460</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3hb_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3hb_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>461</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3hb_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3hb_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>462</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3hb_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3hb_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>463</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3h_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3h_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>464</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3h_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3h_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>465</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3h_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3h_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>466</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3tb_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3tb_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>467</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3tb_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3tb_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>468</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3tb_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3tb_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>469</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3t_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3t_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>470</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3t_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3t_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>471</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox3t_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox3t_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>472</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox4hb_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox4hb_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>473</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox4hb_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox4hb_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>474</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox4hb_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox4hb_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>475</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox4h_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox4h_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>476</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox4h_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox4h_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>477</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox4h_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox4h_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>478</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox4tb_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox4tb_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>479</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox4tb_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox4tb_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>480</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox4tb_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox4tb_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>481</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox4t_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox4t_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>482</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox4t_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox4t_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>483</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox4t_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox4t_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>484</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox5hb_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox5hb_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>485</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox5hb_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox5hb_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>486</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox5hb_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox5hb_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>487</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox5h_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox5h_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>488</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox5h_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox5h_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>489</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox5h_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox5h_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>490</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox5tb_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox5tb_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>491</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox5tb_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox5tb_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>492</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox5tb_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox5tb_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>493</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox5t_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox5t_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>494</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox5t_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox5t_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>495</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_crox5t_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_crox5t_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>496</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_he.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_he.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>497</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_hf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_hf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>498</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_hn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_hn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>499</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_hr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_hr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>500</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_h_symbols.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_h_symbols.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>501</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>502</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>503</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>504</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>505</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>506</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>507</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>508</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>509</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_t_arabic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_t_arabic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>510</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>511</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_t_greek.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_t_greek.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>512</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_t_hebrew.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_t_hebrew.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>513</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_t_symbols.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_t_symbols.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>514</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cu12_t_tibetan.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cu12_t_tibetan.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>515</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cube_mel_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cube_mel_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>516</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cube_mel_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cube_mel_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>517</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cupcakemetoyourleader_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cupcakemetoyourleader_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>518</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cupcakemetoyourleader_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cupcakemetoyourleader_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>519</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cupcakemetoyourleader_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cupcakemetoyourleader_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>520</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_CursivePixel_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_CursivePixel_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>521</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cursor_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cursor_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>522</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_cursor_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_cursor_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>523</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_DigitalDiscoThin_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_DigitalDiscoThin_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>524</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_DigitalDiscoThin_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_DigitalDiscoThin_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>525</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_DigitalDiscoThin_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_DigitalDiscoThin_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>526</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_DigitalDiscoThin_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_DigitalDiscoThin_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>527</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_DigitalDiscoThin_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_DigitalDiscoThin_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>528</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_DigitalDisco_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_DigitalDisco_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>529</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_DigitalDisco_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_DigitalDisco_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>530</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_DigitalDisco_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_DigitalDisco_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>531</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_DigitalDisco_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_DigitalDisco_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>532</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_DigitalDisco_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_DigitalDisco_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>533</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_diodesemimono_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_diodesemimono_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>534</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_disrespectfulteenager_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_disrespectfulteenager_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>535</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_doomalpha04_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_doomalpha04_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>536</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_doomalpha04_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_doomalpha04_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>537</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_dystopia_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_dystopia_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>538</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_dystopia_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_dystopia_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>539</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_eckpixel_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_eckpixel_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>540</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_efraneextracondensed_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_efraneextracondensed_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>541</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_elispe_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_elispe_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>542</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_emoticons21_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_emoticons21_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>543</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Engrish_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Engrish_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>544</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Engrish_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Engrish_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>545</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_etl14thai_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_etl14thai_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>546</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_etl16thai_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_etl16thai_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>547</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_etl24thai_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_etl24thai_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>548</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_eventhrees_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_eventhrees_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>549</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_f10_b_t_japanese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_f10_b_t_japanese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>550</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_f10_b_t_japanese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_f10_b_t_japanese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>551</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_f10_t_japanese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_f10_t_japanese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>552</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_f10_t_japanese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_f10_t_japanese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>553</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_f12_b_t_japanese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_f12_b_t_japanese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>554</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_f12_b_t_japanese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_f12_b_t_japanese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>555</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_f12_t_japanese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_f12_t_japanese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>556</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_f12_t_japanese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_f12_t_japanese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>557</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_f16_b_t_japanese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_f16_b_t_japanese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>558</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_f16_b_t_japanese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_f16_b_t_japanese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>559</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_f16_t_japanese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_f16_t_japanese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>560</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_f16_t_japanese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_f16_t_japanese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>561</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fancypixels_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fancypixels_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>562</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fancypixels_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fancypixels_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>563</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fewture_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fewture_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>564</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fewture_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fewture_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>565</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fewture_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fewture_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>566</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_finderskeepers_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_finderskeepers_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>567</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_finderskeepers_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_finderskeepers_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>568</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_finderskeepers_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_finderskeepers_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>569</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fivepx_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fivepx_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>570</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fourmat_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fourmat_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>571</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fourmat_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fourmat_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>572</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fourmat_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fourmat_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>573</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_freedoomr10_mu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_freedoomr10_mu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>574</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_freedoomr10_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_freedoomr10_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>575</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_freedoomr25_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_freedoomr25_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>576</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_freedoomr25_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_freedoomr25_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>577</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_frigidaire_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_frigidaire_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>578</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_frikativ_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_frikativ_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>579</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_frikativ_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_frikativ_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>580</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_frikativ_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_frikativ_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>581</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub11_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub11_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>582</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub11_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub11_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>583</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub11_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub11_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>584</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub11_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub11_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>585</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>586</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>587</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>588</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub14_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub14_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>589</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub17_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub17_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>590</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub17_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub17_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>591</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub17_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub17_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>592</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub17_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub17_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>593</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub20_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub20_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>594</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub20_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub20_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>595</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub20_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub20_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>596</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub20_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub20_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>597</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub25_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub25_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>598</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub25_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub25_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>599</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub25_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub25_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>600</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub25_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub25_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>601</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub30_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub30_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>602</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub30_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub30_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>603</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub30_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub30_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>604</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub30_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub30_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>605</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub35_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub35_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>606</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub35_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub35_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>607</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub35_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub35_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>608</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub35_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub35_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>609</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub42_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub42_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>610</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub42_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub42_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>611</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub42_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub42_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>612</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub42_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub42_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>613</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub49_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub49_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>614</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fub49_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fub49_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>615</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur11_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur11_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>616</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur11_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur11_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>617</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur11_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur11_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>618</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur11_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur11_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>619</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>620</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>621</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>622</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur14_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur14_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>623</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur17_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur17_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>624</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur17_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur17_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>625</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur17_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur17_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>626</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur17_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur17_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>627</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur20_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur20_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>628</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur20_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur20_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>629</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur20_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur20_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>630</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur20_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur20_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>631</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur25_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur25_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>632</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur25_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur25_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>633</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur25_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur25_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>634</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur25_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur25_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>635</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur30_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur30_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>636</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur30_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur30_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>637</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur30_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur30_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>638</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur30_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur30_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>639</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur35_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur35_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>640</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur35_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur35_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>641</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur35_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur35_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>642</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur35_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur35_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>643</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur42_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur42_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>644</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur42_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur42_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>645</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur42_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur42_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>646</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur42_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur42_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>647</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur49_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur49_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>648</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_fur49_t_symbol.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_fur49_t_symbol.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>649</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ganj_nameh_sans10_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ganj_nameh_sans10_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>650</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ganj_nameh_sans12_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ganj_nameh_sans12_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>651</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ganj_nameh_sans14_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ganj_nameh_sans14_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>652</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ganj_nameh_sans16_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ganj_nameh_sans16_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>653</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_garbagecan_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_garbagecan_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>654</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_garbagecan_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_garbagecan_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>655</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_gb16st_t_1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_gb16st_t_1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>656</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_gb16st_t_2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_gb16st_t_2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>657</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_gb16st_t_3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_gb16st_t_3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>658</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_gb24st_t_1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_gb24st_t_1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>659</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_gb24st_t_2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_gb24st_t_2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>660</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_gb24st_t_3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_gb24st_t_3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>661</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Georgia7px_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Georgia7px_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>662</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Georgia7px_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Georgia7px_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>663</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Georgia7px_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Georgia7px_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>664</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_glasstown_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_glasstown_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>665</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_glasstown_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_glasstown_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>666</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_glasstown_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_glasstown_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>667</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_glasstown_nbp_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_glasstown_nbp_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>668</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_greenbloodserif2_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_greenbloodserif2_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>669</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_guildenstern_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_guildenstern_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>670</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_guildenstern_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_guildenstern_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>671</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_guildenstern_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_guildenstern_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>672</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_guildenstern_nbp_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_guildenstern_nbp_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>673</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_habsburgchancery_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_habsburgchancery_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>674</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_habsburgchancery_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_habsburgchancery_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>675</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_habsburgchancery_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_habsburgchancery_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>676</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_habsburgchancery_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_habsburgchancery_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>677</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_halftone_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_halftone_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>678</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_halftone_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_halftone_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>679</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_halftone_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_halftone_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>680</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_haxrcorp4089_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_haxrcorp4089_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>681</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_haxrcorp4089_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_haxrcorp4089_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>682</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_haxrcorp4089_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_haxrcorp4089_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>683</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_heavybottom_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_heavybottom_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>684</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_heisans_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_heisans_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>685</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB08_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB08_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>686</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>687</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>688</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>689</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB10_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB10_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>690</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>691</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>692</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>693</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB12_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB12_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>694</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>695</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>696</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>697</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB14_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB14_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>698</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>699</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>700</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>701</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB18_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB18_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>702</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>703</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>704</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>705</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB24_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB24_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>706</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>707</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>708</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvB24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvB24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>709</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_HelvetiPixelOutline_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_HelvetiPixelOutline_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>710</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_HelvetiPixelOutline_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_HelvetiPixelOutline_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>711</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_HelvetiPixel_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_HelvetiPixel_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>712</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR08_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR08_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>713</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>714</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>715</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>716</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR10_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR10_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>717</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>718</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>719</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>720</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR12_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR12_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>721</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>722</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>723</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>724</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR14_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR14_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>725</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>726</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>727</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>728</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR18_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR18_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>729</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>730</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>731</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>732</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR24_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR24_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>733</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>734</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>735</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_helvR24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_helvR24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>736</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_iconquadpix_m_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_iconquadpix_m_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>737</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ImpactBits_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ImpactBits_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>738</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb16_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb16_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>739</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb16_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb16_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>740</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb16_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb16_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>741</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb19_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb19_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>742</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb19_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb19_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>743</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb19_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb19_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>744</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb21_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb21_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>745</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb21_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb21_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>746</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb21_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb21_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>747</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb24_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb24_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>748</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb24_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb24_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>749</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb24_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb24_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>750</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb27_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb27_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>751</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb27_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb27_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>752</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb27_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb27_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>753</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb30_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb30_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>754</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb30_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb30_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>755</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb30_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb30_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>756</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb33_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb33_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>757</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb33_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb33_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>758</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb33_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb33_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>759</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb38_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb38_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>760</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb38_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb38_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>761</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb38_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb38_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>762</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb42_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb42_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>763</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb42_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb42_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>764</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb42_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb42_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>765</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb46_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb46_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>766</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb46_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb46_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>767</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb46_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb46_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>768</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb49_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb49_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>769</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb49_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb49_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>770</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb49_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb49_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>771</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb53_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb53_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>772</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb53_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb53_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>773</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb53_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb53_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>774</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb57_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb57_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>775</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inb63_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inb63_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>776</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr16_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr16_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>777</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr16_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr16_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>778</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr16_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr16_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>779</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr19_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr19_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>780</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr19_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr19_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>781</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr19_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr19_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>782</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr21_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr21_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>783</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr21_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr21_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>784</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr21_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr21_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>785</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr24_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr24_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>786</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr24_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr24_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>787</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr24_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr24_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>788</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr24_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr24_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>789</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr27_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr27_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>790</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr27_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr27_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>791</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr27_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr27_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>792</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr27_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr27_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>793</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr30_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr30_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>794</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr30_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr30_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>795</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr30_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr30_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>796</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr30_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr30_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>797</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr33_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr33_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>798</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr33_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr33_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>799</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr33_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr33_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>800</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr33_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr33_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>801</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr38_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr38_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>802</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr38_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr38_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>803</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr38_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr38_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>804</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr38_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr38_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>805</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr42_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr42_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>806</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr42_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr42_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>807</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr42_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr42_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>808</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr42_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr42_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>809</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr46_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr46_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>810</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr46_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr46_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>811</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr46_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr46_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>812</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr46_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr46_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>813</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr49_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr49_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>814</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr49_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr49_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>815</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr49_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr49_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>816</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr49_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr49_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>817</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr53_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr53_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>818</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr53_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr53_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>819</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr53_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr53_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>820</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr53_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr53_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>821</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr57_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr57_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>822</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_inr62_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_inr62_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>823</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_IPAandRUSLCD_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_IPAandRUSLCD_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>824</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_IPAandRUSLCD_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_IPAandRUSLCD_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>825</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_IPAandRUSLCD_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_IPAandRUSLCD_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>826</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_iranian_sans_10_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_iranian_sans_10_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>827</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_iranian_sans_12_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_iranian_sans_12_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>828</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_iranian_sans_14_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_iranian_sans_14_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>829</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_iranian_sans_16_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_iranian_sans_16_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>830</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_iranian_sans_8_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_iranian_sans_8_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>831</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_jinxedwizards_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_jinxedwizards_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>832</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_kibibyte_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_kibibyte_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>833</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_kibibyte_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_kibibyte_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>834</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_koleeko_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_koleeko_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>835</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_koleeko_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_koleeko_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>836</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_koleeko_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_koleeko_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>837</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_koleeko_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_koleeko_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>838</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lastapprenticebold_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lastapprenticebold_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>839</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lastapprenticebold_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lastapprenticebold_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>840</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lastapprenticethin_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lastapprenticethin_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>841</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lastapprenticethin_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lastapprenticethin_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>842</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lastpriestess_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lastpriestess_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>843</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lastpriestess_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lastpriestess_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>844</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_likeminecraft_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_likeminecraft_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>845</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_littlemissloudonbold_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_littlemissloudonbold_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>846</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_littlemissloudonbold_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_littlemissloudonbold_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>847</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso16_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso16_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>848</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso16_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso16_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>849</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso16_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso16_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>850</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>851</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>852</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>853</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso20_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso20_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>854</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso20_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso20_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>855</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso20_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso20_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>856</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso22_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso22_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>857</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso22_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso22_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>858</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso22_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso22_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>859</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>860</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>861</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>862</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso26_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso26_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>863</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso26_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso26_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>864</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso26_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso26_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>865</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso28_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso28_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>866</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso28_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso28_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>867</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso28_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso28_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>868</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso30_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso30_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>869</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso30_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso30_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>870</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso30_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso30_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>871</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso32_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso32_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>872</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso32_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso32_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>873</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso32_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso32_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>874</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso34_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso34_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>875</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso34_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso34_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>876</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso34_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso34_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>877</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso38_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso38_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>878</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso38_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso38_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>879</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso38_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso38_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>880</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso42_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso42_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>881</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso42_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso42_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>882</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso42_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso42_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>883</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso46_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso46_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>884</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso46_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso46_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>885</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso46_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso46_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>886</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso50_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso50_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>887</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso50_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso50_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>888</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso50_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso50_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>889</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso54_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso54_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>890</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso54_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso54_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>891</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso54_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso54_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>892</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso58_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso58_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>893</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso58_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso58_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>894</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso58_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso58_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>895</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso62_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso62_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>896</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso78_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso78_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>897</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_logisoso92_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_logisoso92_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>898</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lord_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lord_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>899</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB08_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB08_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>900</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>901</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>902</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>903</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB10_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB10_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>904</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>905</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>906</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>907</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB12_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB12_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>908</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>909</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>910</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>911</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB14_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB14_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>912</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>913</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>914</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>915</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB18_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB18_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>916</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>917</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>918</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>919</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB19_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB19_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>920</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB19_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB19_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>921</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB19_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB19_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>922</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB19_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB19_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>923</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB24_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB24_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>924</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>925</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>926</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubB24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubB24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>927</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI08_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI08_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>928</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>929</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>930</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>931</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI10_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI10_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>932</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>933</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>934</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>935</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI12_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI12_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>936</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>937</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>938</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>939</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI14_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI14_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>940</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>941</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>942</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>943</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI18_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI18_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>944</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>945</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>946</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>947</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI19_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI19_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>948</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI19_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI19_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>949</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI19_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI19_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>950</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI19_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI19_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>951</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI24_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI24_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>952</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>953</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>954</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubBI24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubBI24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>955</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI08_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI08_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>956</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>957</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>958</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>959</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI10_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI10_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>960</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>961</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>962</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>963</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI12_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI12_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>964</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>965</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>966</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>967</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI14_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI14_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>968</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>969</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>970</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>971</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI18_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI18_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>972</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>973</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>974</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>975</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI19_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI19_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>976</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI19_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI19_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>977</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI19_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI19_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>978</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI19_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI19_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>979</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI24_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI24_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>980</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>981</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>982</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubI24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubI24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>983</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS08_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS08_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>984</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>985</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>986</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>987</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS10_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS10_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>988</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>989</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>990</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>991</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS12_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS12_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>992</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>993</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>994</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>995</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS14_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS14_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>996</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>997</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>998</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>999</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS18_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS18_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1000</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1001</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1002</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1003</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS19_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS19_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1004</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS19_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS19_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1005</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS19_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS19_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1006</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS19_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS19_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1007</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS24_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS24_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1008</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1009</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1010</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBIS24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBIS24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1011</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR08_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR08_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1012</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1013</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1014</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1015</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR10_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR10_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1016</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1017</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1018</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1019</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR12_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR12_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1020</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1021</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1022</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1023</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR14_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR14_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1024</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1025</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1026</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1027</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR18_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR18_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1028</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1029</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1030</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1031</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR19_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR19_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1032</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR19_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR19_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1033</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR19_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR19_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1034</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR19_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR19_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1035</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR24_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR24_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1036</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1037</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1038</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lubR24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lubR24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1039</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS08_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS08_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1040</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1041</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1042</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1043</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS10_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS10_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1044</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1045</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1046</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1047</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS12_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS12_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1048</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1049</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1050</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1051</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS14_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS14_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1052</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1053</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1054</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1055</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS18_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS18_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1056</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1057</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1058</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1059</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS19_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS19_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1060</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS19_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS19_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1061</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS19_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS19_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1062</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS19_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS19_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1063</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS24_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS24_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1064</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1065</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1066</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luBS24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luBS24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1067</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lucasarts_scumm_subtitle_o_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lucasarts_scumm_subtitle_o_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1068</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lucasarts_scumm_subtitle_o_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lucasarts_scumm_subtitle_o_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1069</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lucasarts_scumm_subtitle_o_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lucasarts_scumm_subtitle_o_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1070</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lucasarts_scumm_subtitle_r_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lucasarts_scumm_subtitle_r_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1071</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lucasarts_scumm_subtitle_r_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lucasarts_scumm_subtitle_r_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1072</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lucasarts_scumm_subtitle_r_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lucasarts_scumm_subtitle_r_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1073</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lucasfont_alternate_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lucasfont_alternate_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1074</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lucasfont_alternate_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lucasfont_alternate_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1075</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_lucasfont_alternate_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_lucasfont_alternate_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1076</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS08_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS08_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1077</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1078</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1079</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1080</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS10_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS10_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1081</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1082</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1083</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1084</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS12_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS12_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1085</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1086</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1087</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1088</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS14_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS14_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1089</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1090</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1091</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1092</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS18_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS18_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1093</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1094</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1095</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1096</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS19_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS19_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1097</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS19_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS19_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1098</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS19_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS19_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1099</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS19_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS19_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1100</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS24_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS24_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1101</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1102</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1103</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luIS24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luIS24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1104</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS08_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS08_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1105</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1106</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1107</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1108</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS10_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS10_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1109</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1110</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1111</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1112</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS12_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS12_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1113</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1114</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1115</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1116</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS14_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS14_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1117</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1118</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1119</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1120</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS18_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS18_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1121</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1122</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1123</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1124</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS19_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS19_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1125</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS19_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS19_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1126</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS19_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS19_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1127</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS19_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS19_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1128</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS24_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS24_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1129</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1130</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1131</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_luRS24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_luRS24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1132</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_m2icon_5_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_m2icon_5_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1133</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_m2icon_7_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_m2icon_7_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1134</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_m2icon_9_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_m2icon_9_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1135</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mademoiselle_mel_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mademoiselle_mel_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1136</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mademoiselle_mel_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mademoiselle_mel_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1137</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_maniac_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_maniac_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1138</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_maniac_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_maniac_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1139</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_maniac_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_maniac_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1140</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_maniac_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_maniac_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1141</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_medsans_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_medsans_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1142</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mercutio_basic_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mercutio_basic_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1143</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mercutio_basic_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mercutio_basic_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1144</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mercutio_basic_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mercutio_basic_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1145</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mercutio_basic_nbp_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mercutio_basic_nbp_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1146</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mercutio_sc_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mercutio_sc_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1147</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mercutio_sc_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mercutio_sc_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1148</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mercutio_sc_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mercutio_sc_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1149</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mercutio_sc_nbp_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mercutio_sc_nbp_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1150</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_michaelmouse_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_michaelmouse_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1151</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_micropixel_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_micropixel_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1152</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_micropixel_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_micropixel_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1153</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_micropixel_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_micropixel_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1154</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_micro_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_micro_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1155</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_micro_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_micro_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1156</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_micro_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_micro_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1157</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_micro_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_micro_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1158</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mildras_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mildras_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1159</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mildras_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mildras_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1160</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_minicute_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_minicute_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1161</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_minicute_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_minicute_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1162</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_minimal3x3_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_minimal3x3_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1163</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_minuteconsole_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_minuteconsole_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1164</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_minuteconsole_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_minuteconsole_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1165</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_miranda_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_miranda_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1166</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_miranda_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_miranda_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1167</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_miranda_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_miranda_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1168</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_missingplanet_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_missingplanet_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1169</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_missingplanet_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_missingplanet_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1170</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_missingplanet_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_missingplanet_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1171</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_missingplanet_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_missingplanet_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1172</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_moosenooks_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_moosenooks_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1173</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mozart_nbp_h_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mozart_nbp_h_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1174</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mozart_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mozart_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1175</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mozart_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mozart_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1176</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mozart_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mozart_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1177</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mozart_nbp_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mozart_nbp_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1178</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mystery_quest_24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mystery_quest_24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1179</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mystery_quest_24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mystery_quest_24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1180</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mystery_quest_24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mystery_quest_24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1181</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mystery_quest_28_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mystery_quest_28_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1182</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mystery_quest_28_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mystery_quest_28_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1183</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mystery_quest_28_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mystery_quest_28_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1184</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mystery_quest_32_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mystery_quest_32_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1185</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mystery_quest_32_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mystery_quest_32_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1186</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mystery_quest_36_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mystery_quest_36_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1187</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mystery_quest_42_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mystery_quest_42_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1188</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mystery_quest_48_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mystery_quest_48_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1189</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_mystery_quest_56_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_mystery_quest_56_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1190</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_m_c_kids_nes_credits_font_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_m_c_kids_nes_credits_font_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1191</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB08_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB08_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1192</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1193</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1194</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1195</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB10_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB10_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1196</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1197</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1198</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1199</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB12_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB12_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1200</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1201</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1202</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1203</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB14_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB14_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1204</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1205</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1206</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1207</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB18_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB18_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1208</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1209</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1210</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1211</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB24_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB24_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1212</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1213</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1214</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenB24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenB24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1215</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR08_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR08_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1216</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1217</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1218</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1219</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR10_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR10_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1220</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1221</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1222</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1223</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR12_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR12_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1224</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1225</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1226</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1227</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR14_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR14_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1228</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1229</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1230</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1231</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR18_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR18_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1232</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1233</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1234</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1235</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR24_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR24_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1236</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1237</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1238</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ncenR24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ncenR24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1239</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_nerhoe_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_nerhoe_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1240</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_nerhoe_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_nerhoe_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1241</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_nerhoe_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_nerhoe_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1242</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_neuecraft_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_neuecraft_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1243</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_neuecraft_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_neuecraft_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1244</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_new3x9pixelfont_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_new3x9pixelfont_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1245</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_new3x9pixelfont_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_new3x9pixelfont_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1246</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_new3x9pixelfont_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_new3x9pixelfont_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1247</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_nine_by_five_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_nine_by_five_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1248</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_nine_by_five_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_nine_by_five_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1249</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_nine_by_five_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_nine_by_five_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1250</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_nine_by_five_nbp_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_nine_by_five_nbp_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1251</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_nokiafc22_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_nokiafc22_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1252</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_nokiafc22_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_nokiafc22_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1253</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_nokiafc22_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_nokiafc22_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1254</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_nokiafc22_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_nokiafc22_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1255</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_NokiaLargeBold_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_NokiaLargeBold_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1256</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_NokiaLargeBold_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_NokiaLargeBold_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1257</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_NokiaLargeBold_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_NokiaLargeBold_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1258</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_NokiaSmallBold_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_NokiaSmallBold_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1259</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_NokiaSmallBold_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_NokiaSmallBold_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1260</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_NokiaSmallBold_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_NokiaSmallBold_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1261</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_NokiaSmallPlain_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_NokiaSmallPlain_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1262</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_NokiaSmallPlain_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_NokiaSmallPlain_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1263</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_NokiaSmallPlain_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_NokiaSmallPlain_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1264</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_oldwizard_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_oldwizard_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1265</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_oldwizard_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_oldwizard_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1266</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_oldwizard_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_oldwizard_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1267</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_oldwizard_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_oldwizard_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1268</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_all_1x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_all_1x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1269</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_all_2x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_all_2x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1270</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_all_4x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_all_4x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1271</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_all_6x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_all_6x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1272</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_all_8x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_all_8x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1273</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_app_1x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_app_1x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1274</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_app_2x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_app_2x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1275</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_app_4x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_app_4x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1276</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_app_6x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_app_6x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1277</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_app_8x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_app_8x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1278</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_arrow_1x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_arrow_1x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1279</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_arrow_2x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_arrow_2x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1280</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_arrow_4x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_arrow_4x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1281</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_arrow_6x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_arrow_6x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1282</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_arrow_8x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_arrow_8x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1283</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_check_1x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_check_1x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1284</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_check_2x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_check_2x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1285</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_check_4x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_check_4x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1286</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_check_6x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_check_6x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1287</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_check_8x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_check_8x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1288</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_email_1x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_email_1x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1289</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_email_2x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_email_2x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1290</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_email_4x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_email_4x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1291</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_email_6x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_email_6x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1292</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_email_8x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_email_8x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1293</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_embedded_1x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_embedded_1x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1294</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_embedded_2x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_embedded_2x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1295</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_embedded_4x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_embedded_4x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1296</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_embedded_6x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_embedded_6x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1297</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_embedded_8x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_embedded_8x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1298</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_gui_1x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_gui_1x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1299</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_gui_2x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_gui_2x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1300</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_gui_4x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_gui_4x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1301</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_gui_6x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_gui_6x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1302</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_gui_8x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_gui_8x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1303</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_human_1x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_human_1x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1304</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_human_2x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_human_2x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1305</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_human_4x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_human_4x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1306</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_human_6x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_human_6x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1307</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_human_8x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_human_8x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1308</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_mime_1x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_mime_1x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1309</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_mime_2x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_mime_2x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1310</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_mime_4x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_mime_4x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1311</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_mime_6x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_mime_6x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1312</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_mime_8x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_mime_8x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1313</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_other_1x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_other_1x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1314</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_other_2x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_other_2x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1315</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_other_4x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_other_4x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1316</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_other_6x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_other_6x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1317</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_other_8x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_other_8x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1318</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_play_1x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_play_1x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1319</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_play_2x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_play_2x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1320</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_play_4x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_play_4x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1321</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_play_6x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_play_6x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1322</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_play_8x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_play_8x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1323</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_text_1x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_text_1x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1324</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_text_2x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_text_2x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1325</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_text_4x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_text_4x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1326</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_text_6x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_text_6x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1327</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_text_8x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_text_8x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1328</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_thing_1x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_thing_1x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1329</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_thing_2x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_thing_2x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1330</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_thing_4x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_thing_4x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1331</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_thing_6x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_thing_6x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1332</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_thing_8x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_thing_8x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1333</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_weather_1x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_weather_1x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1334</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_weather_2x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_weather_2x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1335</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_weather_4x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_weather_4x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1336</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_weather_6x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_weather_6x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1337</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_weather_8x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_weather_8x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1338</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_www_1x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_www_1x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1339</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_www_2x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_www_2x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1340</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_www_4x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_www_4x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1341</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_www_6x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_www_6x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1342</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_open_iconic_www_8x_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_open_iconic_www_8x_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1343</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ordinarybasis_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ordinarybasis_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1344</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ordinarybasis_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ordinarybasis_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1345</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ordinarybasis_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ordinarybasis_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1346</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_ordinarybasis_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_ordinarybasis_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1347</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_originalsans_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_originalsans_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1348</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1349</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1350</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1351</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb21_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb21_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1352</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb21_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb21_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1353</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb21_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb21_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1354</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb26_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb26_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1355</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb26_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb26_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1356</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb26_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb26_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1357</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb29_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb29_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1358</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb29_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb29_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1359</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb29_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb29_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1360</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb35_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb35_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1361</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb35_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb35_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1362</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb35_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb35_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1363</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb41_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb41_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1364</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb41_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb41_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1365</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osb41_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osb41_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1366</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_oskool_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_oskool_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1367</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_oskool_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_oskool_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1368</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_oskool_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_oskool_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1369</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1370</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1371</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1372</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr21_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr21_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1373</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr21_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr21_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1374</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr21_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr21_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1375</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr26_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr26_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1376</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr26_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr26_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1377</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr26_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr26_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1378</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr29_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr29_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1379</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr29_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr29_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1380</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr29_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr29_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1381</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr35_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr35_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1382</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr35_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr35_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1383</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr35_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr35_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1384</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr41_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr41_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1385</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr41_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr41_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1386</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_osr41_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_osr41_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1387</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_p01type_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_p01type_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1388</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_p01type_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_p01type_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1389</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_p01type_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_p01type_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1390</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pcsenior_8f.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pcsenior_8f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1391</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pcsenior_8n.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pcsenior_8n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1392</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pcsenior_8r.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pcsenior_8r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1393</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pcsenior_8u.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pcsenior_8u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1394</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pearfont_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pearfont_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1395</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_percent_circle_25_hn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_percent_circle_25_hn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1396</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pieceofcake_mel_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pieceofcake_mel_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1397</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pieceofcake_mel_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pieceofcake_mel_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1398</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Pixellari_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Pixellari_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1399</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Pixellari_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Pixellari_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1400</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Pixellari_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Pixellari_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1401</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Pixellari_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Pixellari_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1402</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Pixellari_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Pixellari_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1403</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pixelle_micro_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pixelle_micro_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1404</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pixelle_micro_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pixelle_micro_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1405</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pixelmordred_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pixelmordred_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1406</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pixelmordred_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pixelmordred_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1407</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pixelmordred_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pixelmordred_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1408</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pixelmordred_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pixelmordred_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1409</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pixelpoiiz_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pixelpoiiz_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1410</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_PixelTheatre_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_PixelTheatre_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1411</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_PixelTheatre_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_PixelTheatre_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1412</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pixzillav1_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pixzillav1_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1413</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pixzillav1_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pixzillav1_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1414</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pixzillav1_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pixzillav1_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1415</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pressstart2p_8f.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pressstart2p_8f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1416</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pressstart2p_8n.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pressstart2p_8n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1417</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pressstart2p_8r.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pressstart2p_8r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1418</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pressstart2p_8u.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pressstart2p_8u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1419</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_press_mel_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_press_mel_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1420</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_press_mel_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_press_mel_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1421</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_princess_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_princess_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1422</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_princess_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_princess_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1423</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont10_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont10_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1424</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont10_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont10_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1425</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont10_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont10_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1426</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1427</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1428</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1429</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont11_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont11_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1430</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont11_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont11_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1431</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont11_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont11_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1432</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont11_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont11_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1433</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont11_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont11_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1434</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont11_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont11_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1435</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont12_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont12_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1436</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont12_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont12_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1437</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont12_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont12_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1438</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1439</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1440</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1441</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont15_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont15_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1442</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont15_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont15_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1443</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont15_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont15_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1444</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont15_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont15_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1445</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont15_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont15_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1446</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont15_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont15_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1447</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont17_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont17_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1448</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont17_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont17_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1449</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont17_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont17_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1450</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont17_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont17_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1451</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont17_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont17_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1452</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont17_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont17_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1453</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont22_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont22_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1454</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont22_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont22_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1455</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont22_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont22_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1456</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont22_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont22_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1457</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont22_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont22_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1458</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont22_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont22_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1459</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont29_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont29_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1460</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont29_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont29_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1461</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont29_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont29_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1462</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont29_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont29_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1463</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont29_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont29_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1464</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_profont29_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_profont29_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1465</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_prospero_bold_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_prospero_bold_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1466</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_prospero_bold_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_prospero_bold_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1467</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_prospero_bold_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_prospero_bold_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1468</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_prospero_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_prospero_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1469</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_prospero_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_prospero_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1470</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_prospero_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_prospero_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1471</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_px437wyse700a_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_px437wyse700a_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1472</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_px437wyse700a_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_px437wyse700a_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1473</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_px437wyse700a_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_px437wyse700a_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1474</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_px437wyse700a_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_px437wyse700a_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1475</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_px437wyse700a_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_px437wyse700a_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1476</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_px437wyse700a_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_px437wyse700a_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1477</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_px437wyse700b_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_px437wyse700b_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1478</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_px437wyse700b_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_px437wyse700b_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1479</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_px437wyse700b_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_px437wyse700b_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1480</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_px437wyse700b_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_px437wyse700b_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1481</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_px437wyse700b_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_px437wyse700b_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1482</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_px437wyse700b_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_px437wyse700b_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1483</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxclassic_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxclassic_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1484</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxclassic_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxclassic_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1485</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxclassic_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxclassic_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1486</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmcgathin_8f.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmcgathin_8f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1487</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmcgathin_8n.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmcgathin_8n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1488</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmcgathin_8r.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmcgathin_8r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1489</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmcgathin_8u.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmcgathin_8u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1490</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmcga_8f.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmcga_8f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1491</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmcga_8n.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmcga_8n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1492</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmcga_8r.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmcga_8r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1493</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmcga_8u.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmcga_8u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1494</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga8_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga8_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1495</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga8_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga8_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1496</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga8_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga8_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1497</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga8_m_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga8_m_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1498</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga8_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga8_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1499</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga8_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga8_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1500</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga8_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga8_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1501</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga8_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga8_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1502</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga9_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga9_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1503</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga9_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga9_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1504</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga9_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga9_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1505</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga9_m_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga9_m_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1506</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga9_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga9_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1507</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga9_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga9_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1508</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga9_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga9_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1509</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplusibmvga9_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplusibmvga9_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1510</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplustandynewtv_8f.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplustandynewtv_8f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1511</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplustandynewtv_8n.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplustandynewtv_8n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1512</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplustandynewtv_8r.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplustandynewtv_8r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1513</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplustandynewtv_8u.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplustandynewtv_8u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1514</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplustandynewtv_8_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplustandynewtv_8_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1515</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_pxplustandynewtv_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_pxplustandynewtv_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1516</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_questgiver_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_questgiver_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1517</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_repress_mel_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_repress_mel_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1518</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_repress_mel_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_repress_mel_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1519</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_resoledbold_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_resoledbold_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1520</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_resoledmedium_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_resoledmedium_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1521</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_robot_de_niro_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_robot_de_niro_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1522</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_robot_de_niro_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_robot_de_niro_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1523</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_robot_de_niro_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_robot_de_niro_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1524</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_roentgen_nbp_h_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_roentgen_nbp_h_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1525</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_roentgen_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_roentgen_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1526</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_roentgen_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_roentgen_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1527</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_roentgen_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_roentgen_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1528</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_roentgen_nbp_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_roentgen_nbp_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1529</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_rosencrantz_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_rosencrantz_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1530</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_rosencrantz_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_rosencrantz_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1531</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_rosencrantz_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_rosencrantz_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1532</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_rosencrantz_nbp_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_rosencrantz_nbp_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1533</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_saikyosansbold8_8n.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_saikyosansbold8_8n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1534</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_saikyosansbold8_8u.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_saikyosansbold8_8u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1535</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_samim_10_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_samim_10_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1536</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_samim_12_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_samim_12_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1537</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_samim_14_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_samim_14_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1538</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_samim_16_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_samim_16_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1539</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_samim_fd_10_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_samim_fd_10_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1540</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_samim_fd_12_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_samim_fd_12_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1541</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_samim_fd_14_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_samim_fd_14_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1542</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_samim_fd_16_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_samim_fd_16_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1543</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_sandyforest_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_sandyforest_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1544</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_sandyforest_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_sandyforest_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1545</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_sandyforest_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_sandyforest_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1546</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_scrum_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_scrum_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1547</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_scrum_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_scrum_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1548</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_scrum_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_scrum_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1549</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_secretaryhand_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_secretaryhand_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1550</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_secretaryhand_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_secretaryhand_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1551</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_secretaryhand_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_secretaryhand_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1552</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_secretaryhand_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_secretaryhand_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1553</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_seraphimb1_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_seraphimb1_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1554</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_shylock_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_shylock_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1555</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_shylock_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_shylock_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1556</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_shylock_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_shylock_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1557</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_shylock_nbp_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_shylock_nbp_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1558</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_siji_t_6x10.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_siji_t_6x10.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1559</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_simple1_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_simple1_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1560</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_simple1_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_simple1_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1561</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_simple1_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_simple1_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1562</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_sirclivethebold_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_sirclivethebold_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1563</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_sirclivethebold_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_sirclivethebold_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1564</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_sirclive_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_sirclive_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1565</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_sirclive_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_sirclive_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1566</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_sisterserif_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_sisterserif_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1567</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_smallsimple_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_smallsimple_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1568</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_smallsimple_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_smallsimple_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1569</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_smart_patrol_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_smart_patrol_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1570</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_smart_patrol_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_smart_patrol_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1571</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_smart_patrol_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_smart_patrol_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1572</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_smolfont_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_smolfont_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1573</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_smolfont_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_smolfont_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1574</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_smolfont_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_smolfont_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1575</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_sonicmania_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_sonicmania_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1576</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_sonicmania_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_sonicmania_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1577</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen12x24_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen12x24_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1578</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen12x24_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen12x24_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1579</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen12x24_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen12x24_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1580</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen12x24_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen12x24_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1581</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen12x24_mu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen12x24_mu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1582</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen16x32_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen16x32_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1583</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen16x32_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen16x32_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1584</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen16x32_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen16x32_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1585</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen16x32_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen16x32_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1586</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen16x32_mu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen16x32_mu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1587</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen32x64_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen32x64_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1588</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen32x64_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen32x64_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1589</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen32x64_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen32x64_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1590</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen32x64_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen32x64_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1591</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen32x64_mu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen32x64_mu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1592</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen5x8_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen5x8_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1593</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen5x8_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen5x8_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1594</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen5x8_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen5x8_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1595</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen5x8_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen5x8_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1596</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen5x8_mu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen5x8_mu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1597</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen6x12_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen6x12_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1598</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen6x12_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen6x12_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1599</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen6x12_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen6x12_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1600</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen6x12_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen6x12_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1601</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen6x12_mu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen6x12_mu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1602</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen8x16_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen8x16_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1603</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen8x16_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen8x16_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1604</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen8x16_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen8x16_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1605</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen8x16_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen8x16_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1606</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_spleen8x16_mu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_spleen8x16_mu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1607</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_squeezed_b6_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_squeezed_b6_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1608</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_squeezed_b6_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_squeezed_b6_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1609</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_squeezed_b7_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_squeezed_b7_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1610</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_squeezed_b7_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_squeezed_b7_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1611</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_squeezed_r6_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_squeezed_r6_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1612</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_squeezed_r6_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_squeezed_r6_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1613</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_squeezed_r7_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_squeezed_r7_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1614</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_squeezed_r7_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_squeezed_r7_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1615</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_squirrel_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_squirrel_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1616</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_squirrel_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_squirrel_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1617</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_squirrel_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_squirrel_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1618</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_standardized3x5_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_standardized3x5_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1619</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_sticker100complete_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_sticker100complete_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1620</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_sticker100complete_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_sticker100complete_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1621</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_sticker_mel_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_sticker_mel_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1622</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_sticker_mel_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_sticker_mel_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1623</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_all_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_all_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1624</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_building_real_estate_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_building_real_estate_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1625</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_business_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_business_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1626</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_coding_apps_websites_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_coding_apps_websites_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1627</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_computers_devices_electronics_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_computers_devices_electronics_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1628</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_content_files_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_content_files_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1629</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_design_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_design_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1630</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_ecology_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_ecology_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1631</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_email_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_email_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1632</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_entertainment_events_hobbies_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_entertainment_events_hobbies_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1633</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_food_drink_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_food_drink_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1634</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_hand_signs_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_hand_signs_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1635</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_health_beauty_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_health_beauty_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1636</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_action_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_action_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1637</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_alert_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_alert_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1638</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_audio_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_audio_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1639</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_calendar_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_calendar_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1640</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_chart_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_chart_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1641</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_circle_triangle_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_circle_triangle_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1642</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_cog_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_cog_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1643</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_cursor_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_cursor_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1644</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_dial_pad_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_dial_pad_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1645</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_edit_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_edit_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1646</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_expand_shrink_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_expand_shrink_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1647</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_eye_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_eye_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1648</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_file_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_file_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1649</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_help_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_help_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1650</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_hierarchy_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_hierarchy_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1651</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_home_menu_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_home_menu_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1652</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_id_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_id_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1653</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_key_lock_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_key_lock_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1654</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_link_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_link_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1655</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_loading_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_loading_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1656</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_login_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_login_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1657</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_other_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_other_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1658</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_paginate_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_paginate_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1659</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_search_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_search_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1660</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_setting_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_setting_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1661</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_share_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_share_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1662</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_text_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_text_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1663</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_wifi_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_wifi_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1664</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_interface_essential_zoom_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_interface_essential_zoom_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1665</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_internet_network_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_internet_network_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1666</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_logo_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_logo_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1667</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_map_navigation_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_map_navigation_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1668</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_money_payments_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_money_payments_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1669</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_music_audio_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_music_audio_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1670</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_pet_animals_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_pet_animals_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1671</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_phone_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_phone_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1672</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_photography_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_photography_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1673</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_romance_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_romance_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1674</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_school_science_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_school_science_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1675</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_shopping_shipping_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_shopping_shipping_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1676</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_social_rewards_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_social_rewards_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1677</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_technology_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_technology_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1678</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_transportation_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_transportation_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1679</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_travel_wayfinding_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_travel_wayfinding_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1680</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_users_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_users_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1681</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_video_movies_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_video_movies_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1682</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_streamline_weather_t.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_streamline_weather_t.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1683</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_stylishcharm_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_stylishcharm_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1684</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_stylishcharm_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_stylishcharm_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1685</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_synchronizer_nbp_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_synchronizer_nbp_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1686</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_synchronizer_nbp_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_synchronizer_nbp_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1687</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_synchronizer_nbp_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_synchronizer_nbp_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1688</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11b_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11b_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1689</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11b_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11b_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1690</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11b_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11b_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1691</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11b_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11b_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1692</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11b_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11b_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1693</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11b_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11b_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1694</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11b_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11b_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1695</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11b_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11b_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1696</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1697</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1698</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1699</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1700</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1701</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1702</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1703</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1704</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_11_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_11_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1705</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12b_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12b_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1706</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12b_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12b_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1707</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12b_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12b_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1708</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12b_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12b_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1709</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12b_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12b_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1710</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12b_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12b_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1711</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12b_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12b_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1712</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12b_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12b_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1713</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1714</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1715</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1716</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1717</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1718</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1719</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1720</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1721</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13b_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13b_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1722</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13b_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13b_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1723</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13b_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13b_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1724</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13b_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13b_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1725</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13b_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13b_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1726</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13b_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13b_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1727</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13b_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13b_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1728</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13b_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13b_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1729</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1730</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1731</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1732</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1733</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1734</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1735</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1736</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_13_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_13_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1737</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14b_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14b_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1738</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14b_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14b_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1739</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14b_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14b_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1740</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14b_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14b_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1741</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14b_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14b_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1742</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14b_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14b_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1743</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14b_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14b_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1744</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14b_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14b_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1745</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1746</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1747</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1748</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1749</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1750</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1751</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1752</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1753</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15b_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15b_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1754</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15b_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15b_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1755</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15b_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15b_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1756</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15b_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15b_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1757</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15b_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15b_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1758</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15b_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15b_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1759</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15b_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15b_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1760</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15b_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15b_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1761</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1762</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1763</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1764</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1765</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1766</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1767</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1768</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_15_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_15_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1769</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16b_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16b_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1770</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16b_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16b_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1771</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16b_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16b_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1772</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16b_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16b_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1773</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16b_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16b_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1774</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16b_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16b_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1775</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16b_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16b_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1776</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16b_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16b_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1777</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1778</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1779</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1780</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1781</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1782</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1783</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1784</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_16_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_16_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1785</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17b_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17b_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1786</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17b_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17b_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1787</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17b_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17b_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1788</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17b_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17b_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1789</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17b_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17b_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1790</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17b_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17b_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1791</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17b_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17b_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1792</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17b_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17b_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1793</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1794</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1795</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1796</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1797</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1798</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1799</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1800</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_17_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_17_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1801</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18b_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18b_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1802</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18b_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18b_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1803</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18b_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18b_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1804</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18b_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18b_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1805</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18b_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18b_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1806</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18b_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18b_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1807</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18b_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18b_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1808</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18b_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18b_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1809</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1810</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1811</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1812</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1813</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1814</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1815</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1816</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1817</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22b_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22b_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1818</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22b_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22b_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1819</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22b_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22b_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1820</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22b_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22b_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1821</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22b_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22b_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1822</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22b_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22b_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1823</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22b_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22b_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1824</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22b_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22b_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1825</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1826</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1827</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1828</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1829</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1830</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1831</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1832</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_t0_22_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_t0_22_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1833</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tallpixelextended_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tallpixelextended_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1834</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tallpixelextended_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tallpixelextended_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1835</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tallpixelextended_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tallpixelextended_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1836</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tallpix_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tallpix_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1837</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenfatguys_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenfatguys_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1838</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenfatguys_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenfatguys_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1839</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenfatguys_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenfatguys_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1840</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenfatguys_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenfatguys_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1841</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenfatguys_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenfatguys_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1842</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenstamps_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenstamps_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1843</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenstamps_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenstamps_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1844</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenstamps_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenstamps_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1845</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenstamps_mu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenstamps_mu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1846</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenthinguys_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenthinguys_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1847</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenthinguys_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenthinguys_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1848</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenthinguys_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenthinguys_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1849</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenthinguys_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenthinguys_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1850</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenthinguys_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenthinguys_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1851</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenthinnerguys_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenthinnerguys_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1852</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenthinnerguys_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenthinnerguys_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1853</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenthinnerguys_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenthinnerguys_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1854</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenthinnerguys_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenthinnerguys_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1855</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tenthinnerguys_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tenthinnerguys_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1856</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Terminal_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Terminal_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1857</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Terminal_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Terminal_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1858</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_threepix_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_threepix_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1859</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1860</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1861</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1862</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1863</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1864</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1865</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1866</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1867</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1868</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1869</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1870</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1871</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1872</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1873</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1874</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1875</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1876</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timB24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timB24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1877</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_TimesNewPixel_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_TimesNewPixel_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1878</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR08_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR08_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1879</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR08_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR08_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1880</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR08_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR08_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1881</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR10_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR10_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1882</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR10_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR10_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1883</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR10_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR10_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1884</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR12_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR12_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1885</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR12_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR12_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1886</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR12_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR12_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1887</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR14_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR14_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1888</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR14_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR14_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1889</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR14_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR14_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1890</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR18_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR18_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1891</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR18_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR18_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1892</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR18_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR18_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1893</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1894</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1895</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_timR24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_timR24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1896</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tiny5_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tiny5_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1897</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tiny5_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tiny5_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1898</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tiny5_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tiny5_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1899</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tiny5_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tiny5_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1900</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tinyface_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tinyface_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1901</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tinyface_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tinyface_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1902</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tinypixie2_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tinypixie2_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1903</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tinytim_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tinytim_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1904</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tinytim_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tinytim_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1905</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tinytim_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tinytim_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1906</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tinyunicode_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tinyunicode_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1907</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tinyunicode_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tinyunicode_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1908</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tinyunicode_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tinyunicode_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1909</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tiny_gk_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tiny_gk_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1910</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tiny_simon_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tiny_simon_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1911</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tiny_simon_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tiny_simon_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1912</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tom_thumb_4x6_me.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tom_thumb_4x6_me.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1913</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tom_thumb_4x6_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tom_thumb_4x6_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1914</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tom_thumb_4x6_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tom_thumb_4x6_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1915</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tom_thumb_4x6_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tom_thumb_4x6_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1916</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tom_thumb_4x6_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tom_thumb_4x6_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1917</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tom_thumb_4x6_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tom_thumb_4x6_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1918</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tom_thumb_4x6_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tom_thumb_4x6_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1919</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tom_thumb_4x6_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tom_thumb_4x6_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1920</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tom_thumb_4x6_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tom_thumb_4x6_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1921</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tooseornament_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tooseornament_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1922</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tooseornament_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tooseornament_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1923</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_tooseornament_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_tooseornament_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1924</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_torussansbold8_8n.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_torussansbold8_8n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1925</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_torussansbold8_8r.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_torussansbold8_8r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1926</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_torussansbold8_8u.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_torussansbold8_8u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1927</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_trixel_square_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_trixel_square_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1928</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_trixel_square_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_trixel_square_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1929</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_trixel_square_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_trixel_square_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1930</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_twelvedings_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_twelvedings_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1931</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_u8glib_4_hf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_u8glib_4_hf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1932</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_u8glib_4_hr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_u8glib_4_hr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1933</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_u8glib_4_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_u8glib_4_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1934</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_u8glib_4_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_u8glib_4_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1935</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_h_symbols.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_h_symbols.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1936</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1937</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1938</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1939</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_0_72_73.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_0_72_73.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1940</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_0_75.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_0_75.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1941</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_0_76.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_0_76.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1942</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_0_77.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_0_77.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1943</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_0_78_79.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_0_78_79.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1944</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_0_86.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_0_86.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1945</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_72_73.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_72_73.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1946</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_75.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_75.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1947</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_76.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_76.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1948</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_77.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_77.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1949</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_78_79.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_78_79.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1950</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_86.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_86.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1951</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_animals.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_animals.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1952</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_arabic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_arabic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1953</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_bengali.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_bengali.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1954</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_cards.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_cards.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1955</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_chinese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_chinese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1956</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_chinese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_chinese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1957</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_chinese3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_chinese3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1958</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_cyrillic.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_cyrillic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1959</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_devanagari.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_devanagari.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1960</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_domino.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_domino.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1961</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_emoticons.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_emoticons.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1962</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_extended.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_extended.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1963</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_gb2312.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_gb2312.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1964</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_gb2312a.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_gb2312a.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1965</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_gb2312b.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_gb2312b.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1966</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_greek.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_greek.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1967</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_hebrew.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_hebrew.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1968</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_japanese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_japanese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1969</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_japanese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_japanese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1970</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_japanese3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_japanese3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1971</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_korean1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_korean1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1972</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_korean2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_korean2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1973</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_latin.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_latin.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1974</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_polish.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_polish.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1975</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_symbols.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_symbols.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1976</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_tibetan.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_tibetan.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1977</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_urdu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_urdu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1978</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_vietnamese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_vietnamese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1979</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_vietnamese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_vietnamese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1980</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_unifont_t_weather.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_unifont_t_weather.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1981</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_UnnamedDOSFontIV_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_UnnamedDOSFontIV_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1982</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Untitled16PixelSansSerifBitmap_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Untitled16PixelSansSerifBitmap_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1983</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_utopia24_te.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_utopia24_te.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1984</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_utopia24_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_utopia24_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1985</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_utopia24_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_utopia24_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1986</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_utopia24_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_utopia24_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1987</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_VCR_OSD_mf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_VCR_OSD_mf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1988</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_VCR_OSD_mn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_VCR_OSD_mn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1989</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_VCR_OSD_mr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_VCR_OSD_mr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1990</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_VCR_OSD_mu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_VCR_OSD_mu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1991</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_VCR_OSD_tf.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_VCR_OSD_tf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1992</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_VCR_OSD_tn.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_VCR_OSD_tn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1993</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_VCR_OSD_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_VCR_OSD_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1994</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_VCR_OSD_tu.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_VCR_OSD_tu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1995</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_victoriabold8_8n.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_victoriabold8_8n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1996</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_victoriabold8_8r.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_victoriabold8_8r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1997</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_victoriabold8_8u.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_victoriabold8_8u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1998</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_victoriamedium8_8n.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_victoriamedium8_8n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>1999</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_victoriamedium8_8r.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_victoriamedium8_8r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2000</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_victoriamedium8_8u.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_victoriamedium8_8u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2001</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_waffle_t_all.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_waffle_t_all.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2002</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wedge_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wedge_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2003</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_Wizzard_tr.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_Wizzard_tr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2004</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy12_t_chinese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy12_t_chinese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2005</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy12_t_chinese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy12_t_chinese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2006</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy12_t_chinese3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy12_t_chinese3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2007</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy12_t_gb2312.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy12_t_gb2312.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2008</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy12_t_gb2312a.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy12_t_gb2312a.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2009</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy12_t_gb2312b.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy12_t_gb2312b.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2010</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy13_t_chinese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy13_t_chinese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2011</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy13_t_chinese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy13_t_chinese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2012</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy13_t_chinese3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy13_t_chinese3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2013</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy13_t_gb2312.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy13_t_gb2312.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2014</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy13_t_gb2312a.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy13_t_gb2312a.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2015</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy13_t_gb2312b.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy13_t_gb2312b.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2016</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy14_t_chinese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy14_t_chinese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2017</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy14_t_chinese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy14_t_chinese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2018</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy14_t_chinese3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy14_t_chinese3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2019</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy14_t_gb2312.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy14_t_gb2312.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2020</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy14_t_gb2312a.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy14_t_gb2312a.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2021</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy14_t_gb2312b.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy14_t_gb2312b.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2022</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy15_t_chinese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy15_t_chinese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2023</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy15_t_chinese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy15_t_chinese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2024</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy15_t_chinese3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy15_t_chinese3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2025</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy15_t_gb2312.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy15_t_gb2312.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2026</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy15_t_gb2312a.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy15_t_gb2312a.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2027</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy15_t_gb2312b.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy15_t_gb2312b.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2028</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy16_t_chinese1.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy16_t_chinese1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2029</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy16_t_chinese2.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy16_t_chinese2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2030</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy16_t_chinese3.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy16_t_chinese3.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2031</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy16_t_gb2312.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy16_t_gb2312.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2032</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy16_t_gb2312a.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy16_t_gb2312a.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2033</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8g2_font_wqy16_t_gb2312b.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_font_wqy16_t_gb2312b.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2034</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_5x7_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_5x7_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2035</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_5x7_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_5x7_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2036</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_5x7_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_5x7_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2037</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_5x8_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_5x8_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2038</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_5x8_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_5x8_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2039</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_5x8_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_5x8_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2040</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_7x14B_1x2_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_7x14B_1x2_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2041</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_7x14B_1x2_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_7x14B_1x2_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2042</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_7x14B_1x2_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_7x14B_1x2_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2043</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_7x14_1x2_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_7x14_1x2_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2044</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_7x14_1x2_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_7x14_1x2_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2045</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_7x14_1x2_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_7x14_1x2_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2046</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_8x13B_1x2_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_8x13B_1x2_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2047</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_8x13B_1x2_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_8x13B_1x2_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2048</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_8x13B_1x2_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_8x13B_1x2_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2049</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_8x13_1x2_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_8x13_1x2_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2050</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_8x13_1x2_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_8x13_1x2_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2051</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_8x13_1x2_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_8x13_1x2_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2052</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_amstrad_cpc_extended_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_amstrad_cpc_extended_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2053</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_amstrad_cpc_extended_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_amstrad_cpc_extended_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2054</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_amstrad_cpc_extended_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_amstrad_cpc_extended_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2055</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_amstrad_cpc_extended_u.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_amstrad_cpc_extended_u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2056</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_artossans8_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_artossans8_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2057</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_artossans8_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_artossans8_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2058</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_artossans8_u.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_artossans8_u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2059</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_artosserif8_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_artosserif8_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2060</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_artosserif8_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_artosserif8_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2061</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_artosserif8_u.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_artosserif8_u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2062</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_chroma48medium8_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_chroma48medium8_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2063</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_chroma48medium8_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_chroma48medium8_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2064</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_chroma48medium8_u.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_chroma48medium8_u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2065</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_courB18_2x3_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_courB18_2x3_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2066</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_courB18_2x3_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_courB18_2x3_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2067</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_courB18_2x3_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_courB18_2x3_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2068</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_courB24_3x4_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_courB24_3x4_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2069</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_courB24_3x4_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_courB24_3x4_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2070</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_courB24_3x4_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_courB24_3x4_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2071</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_courR18_2x3_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_courR18_2x3_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2072</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_courR18_2x3_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_courR18_2x3_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2073</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_courR18_2x3_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_courR18_2x3_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2074</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_courR24_3x4_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_courR24_3x4_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2075</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_courR24_3x4_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_courR24_3x4_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2076</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_courR24_3x4_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_courR24_3x4_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2077</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inb21_2x4_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inb21_2x4_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2078</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inb21_2x4_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inb21_2x4_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2079</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inb21_2x4_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inb21_2x4_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2080</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inb33_3x6_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inb33_3x6_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2081</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inb33_3x6_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inb33_3x6_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2082</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inb33_3x6_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inb33_3x6_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2083</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inb46_4x8_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inb46_4x8_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2084</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inb46_4x8_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inb46_4x8_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2085</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inb46_4x8_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inb46_4x8_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2086</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inr21_2x4_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inr21_2x4_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2087</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inr21_2x4_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inr21_2x4_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2088</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inr21_2x4_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inr21_2x4_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2089</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inr33_3x6_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inr33_3x6_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2090</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inr33_3x6_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inr33_3x6_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2091</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inr33_3x6_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inr33_3x6_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2092</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inr46_4x8_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inr46_4x8_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2093</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inr46_4x8_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inr46_4x8_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2094</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_inr46_4x8_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_inr46_4x8_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2095</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_lucasarts_scumm_subtitle_o_2x2_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_lucasarts_scumm_subtitle_o_2x2_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2096</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_lucasarts_scumm_subtitle_o_2x2_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_lucasarts_scumm_subtitle_o_2x2_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2097</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_lucasarts_scumm_subtitle_o_2x2_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_lucasarts_scumm_subtitle_o_2x2_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2098</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_lucasarts_scumm_subtitle_r_2x2_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_lucasarts_scumm_subtitle_r_2x2_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2099</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_lucasarts_scumm_subtitle_r_2x2_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_lucasarts_scumm_subtitle_r_2x2_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2100</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_lucasarts_scumm_subtitle_r_2x2_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_lucasarts_scumm_subtitle_r_2x2_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2101</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_arrow_1x1.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_arrow_1x1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2102</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_arrow_2x2.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_arrow_2x2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2103</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_arrow_4x4.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_arrow_4x4.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2104</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_arrow_8x8.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_arrow_8x8.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2105</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_check_1x1.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_check_1x1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2106</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_check_2x2.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_check_2x2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2107</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_check_4x4.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_check_4x4.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2108</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_check_8x8.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_check_8x8.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2109</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_embedded_1x1.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_embedded_1x1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2110</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_embedded_2x2.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_embedded_2x2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2111</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_embedded_4x4.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_embedded_4x4.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2112</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_embedded_8x8.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_embedded_8x8.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2113</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_play_1x1.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_play_1x1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2114</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_play_2x2.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_play_2x2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2115</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_play_4x4.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_play_4x4.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2116</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_play_8x8.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_play_8x8.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2117</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_thing_1x1.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_thing_1x1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2118</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_thing_2x2.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_thing_2x2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2119</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_thing_4x4.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_thing_4x4.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2120</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_thing_8x8.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_thing_8x8.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2121</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_weather_1x1.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_weather_1x1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2122</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_weather_2x2.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_weather_2x2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2123</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_weather_4x4.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_weather_4x4.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2124</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_open_iconic_weather_8x8.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_open_iconic_weather_8x8.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2125</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pcsenior_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pcsenior_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2126</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pcsenior_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pcsenior_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2127</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pcsenior_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pcsenior_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2128</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pcsenior_u.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pcsenior_u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2129</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pressstart2p_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pressstart2p_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2130</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pressstart2p_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pressstart2p_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2131</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pressstart2p_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pressstart2p_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2132</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pressstart2p_u.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pressstart2p_u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2133</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_profont29_2x3_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_profont29_2x3_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2134</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_profont29_2x3_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_profont29_2x3_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2135</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_profont29_2x3_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_profont29_2x3_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2136</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_px437wyse700a_2x2_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_px437wyse700a_2x2_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2137</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_px437wyse700a_2x2_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_px437wyse700a_2x2_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2138</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_px437wyse700a_2x2_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_px437wyse700a_2x2_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2139</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_px437wyse700b_2x2_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_px437wyse700b_2x2_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2140</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_px437wyse700b_2x2_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_px437wyse700b_2x2_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2141</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_px437wyse700b_2x2_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_px437wyse700b_2x2_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2142</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pxplusibmcgathin_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pxplusibmcgathin_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2143</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pxplusibmcgathin_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pxplusibmcgathin_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2144</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pxplusibmcgathin_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pxplusibmcgathin_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2145</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pxplusibmcgathin_u.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pxplusibmcgathin_u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2146</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pxplusibmcga_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pxplusibmcga_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2147</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pxplusibmcga_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pxplusibmcga_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2148</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pxplusibmcga_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pxplusibmcga_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2149</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pxplusibmcga_u.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pxplusibmcga_u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2150</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pxplustandynewtv_f.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pxplustandynewtv_f.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2151</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pxplustandynewtv_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pxplustandynewtv_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2152</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pxplustandynewtv_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pxplustandynewtv_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2153</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_pxplustandynewtv_u.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_pxplustandynewtv_u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2154</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_saikyosansbold8_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_saikyosansbold8_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2155</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_saikyosansbold8_u.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_saikyosansbold8_u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2156</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_torussansbold8_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_torussansbold8_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2157</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_torussansbold8_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_torussansbold8_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2158</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_torussansbold8_u.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_torussansbold8_u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2159</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_victoriabold8_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_victoriabold8_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2160</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_victoriabold8_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_victoriabold8_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2161</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_victoriabold8_u.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_victoriabold8_u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2162</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_victoriamedium8_n.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_victoriamedium8_n.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2163</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_victoriamedium8_r.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_victoriamedium8_r.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>2164</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/build/single_font_files/u8x8_font_victoriamedium8_u.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_font_victoriamedium8_u.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/FONT/BMF2BDF</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>2165</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/bmf2bdf/bmf2bdf.c</PathWithFileName>
      <FilenameWithoutPath>bmf2bdf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/FONT/BDFCONV</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>2166</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/bdfconv/bdf_8x8.c</PathWithFileName>
      <FilenameWithoutPath>bdf_8x8.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>2167</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/bdfconv/bdf_font.c</PathWithFileName>
      <FilenameWithoutPath>bdf_font.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>2168</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/bdfconv/bdf_glyph.c</PathWithFileName>
      <FilenameWithoutPath>bdf_glyph.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>2169</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/bdfconv/bdf_kern.c</PathWithFileName>
      <FilenameWithoutPath>bdf_kern.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>2170</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/bdfconv/bdf_map.c</PathWithFileName>
      <FilenameWithoutPath>bdf_map.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>2171</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/bdfconv/bdf_parser.c</PathWithFileName>
      <FilenameWithoutPath>bdf_parser.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>2172</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/bdfconv/bdf_rle.c</PathWithFileName>
      <FilenameWithoutPath>bdf_rle.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>2173</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/bdfconv/bdf_tga.c</PathWithFileName>
      <FilenameWithoutPath>bdf_tga.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>2174</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/bdfconv/fd.c</PathWithFileName>
      <FilenameWithoutPath>fd.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>2175</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/font/bdfconv/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/CODEBUILD</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>2176</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/codebuild/codebuild.c</PathWithFileName>
      <FilenameWithoutPath>codebuild.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/TOOLS/BUILDCPP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>19</GroupNumber>
      <FileNumber>2177</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/tools/buildcpp/buildcpp.c</PathWithFileName>
      <FilenameWithoutPath>buildcpp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/XBM_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>20</GroupNumber>
      <FileNumber>2178</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/xbm_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/TEXT_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>21</GroupNumber>
      <FileNumber>2179</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/text_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/STRING_LIST_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>22</GroupNumber>
      <FileNumber>2180</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/string_list_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/SELECTION_LIST_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>23</GroupNumber>
      <FileNumber>2181</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/selection_list_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/RBOX_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>24</GroupNumber>
      <FileNumber>2182</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/rbox_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/POLYGON_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>25</GroupNumber>
      <FileNumber>2183</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/polygon_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/LINE_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>26</GroupNumber>
      <FileNumber>2184</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/line_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/INVERTED_TEXT_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>2185</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/inverted_text_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/INTERSECTION_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>28</GroupNumber>
      <FileNumber>2186</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/intersection_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/HELLO_WORLD_8X8</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>2187</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/hello_world_8x8/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/HBITMAP_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>30</GroupNumber>
      <FileNumber>2188</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/hbitmap_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/FRAME_ROTATE_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>31</GroupNumber>
      <FileNumber>2189</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/frame_rotate_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/ELLIPSE_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>32</GroupNumber>
      <FileNumber>2190</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/ellipse_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/DRAW_UTF8_LINE_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>33</GroupNumber>
      <FileNumber>2191</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/draw_utf8_line_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/COMMON</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>34</GroupNumber>
      <FileNumber>2192</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/common/u8x8_d_utf8.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_d_utf8.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/CLIP_TEST_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>2193</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/clip_test_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/CLIP_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>36</GroupNumber>
      <FileNumber>2194</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/clip_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/CIRCLE_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>37</GroupNumber>
      <FileNumber>2195</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/circle_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/CHINESE_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>38</GroupNumber>
      <FileNumber>2196</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/chinese_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/UTF8/BOX_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>39</GroupNumber>
      <FileNumber>2197</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/utf8/box_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/TGA/XBM_SPEED</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>40</GroupNumber>
      <FileNumber>2198</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/tga/xbm_speed/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/TGA/WORD_CLOUD</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>41</GroupNumber>
      <FileNumber>2199</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/tga/word_cloud/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/TGA/TEXT_PICTURE_LOOP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>42</GroupNumber>
      <FileNumber>2200</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/tga/text_picture_loop/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/TGA/REF_MAN_PICS_U8G2</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>43</GroupNumber>
      <FileNumber>2201</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/tga/ref_man_pics_u8g2/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/TGA/REF_MAN_PICS_8X8</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>44</GroupNumber>
      <FileNumber>2202</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/tga/ref_man_pics_8x8/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/TGA/MAPGEN</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>45</GroupNumber>
      <FileNumber>2203</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/tga/mapgen/mapgen.c</PathWithFileName>
      <FilenameWithoutPath>mapgen.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>45</GroupNumber>
      <FileNumber>2204</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/tga/mapgen/u8g2_d_tga.c</PathWithFileName>
      <FilenameWithoutPath>u8g2_d_tga.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/TGA/HELLO_WORLD_8X8</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>46</GroupNumber>
      <FileNumber>2205</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/tga/hello_world_8x8/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/TGA/EXAMPLE</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>47</GroupNumber>
      <FileNumber>2206</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/tga/example/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/TGA/COMMON</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>48</GroupNumber>
      <FileNumber>2207</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/tga/common/u8x8_d_tga.c</PathWithFileName>
      <FilenameWithoutPath>u8x8_d_tga.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/STDIO</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>49</GroupNumber>
      <FileNumber>2208</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/stdio/test.c</PathWithFileName>
      <FilenameWithoutPath>test.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/SDL/XBM2</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>2209</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/sdl/xbm2/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/SDL/XBM</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>51</GroupNumber>
      <FileNumber>2210</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/sdl/xbm/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/SDL/VIETNAMESE</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>52</GroupNumber>
      <FileNumber>2211</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/sdl/vietnamese/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/SDL/UTF8_TEST_8X8</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>53</GroupNumber>
      <FileNumber>2212</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/sdl/utf8_test_8x8/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/SDL/UNIFONT_JP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>54</GroupNumber>
      <FileNumber>2213</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/sdl/unifont_jp/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/SDL/UI</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>55</GroupNumber>
      <FileNumber>2214</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/sdl/ui/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>LIB/U8G2/SYS/SDL/U8LOG_U8X8</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>56</GroupNumber>
      <FileNumber>2215</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>lib/u8g2/sys/sdl/u8log_u8x8/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
